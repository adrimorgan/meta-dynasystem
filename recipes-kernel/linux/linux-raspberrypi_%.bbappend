CMDLINE_append = " logo.nologo"