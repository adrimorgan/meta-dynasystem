PACKAGECONFIG_append = " eglfs kms"
