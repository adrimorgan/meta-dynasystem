PACKAGECONFIG_remove = " lang-all"
PACKAGECONFIG_append = " lang-es_ES lang-en_GB"
